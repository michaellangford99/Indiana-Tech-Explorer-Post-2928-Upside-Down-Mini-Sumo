# Repository michaellangford99/Indiana-Tech-Explorer-Post-2928-Upside-Down-Mini-Sumo

File README.md:

# Indiana-Tech-Explorer-Post-2928-Upside-Down-Mini-Sumo

## KiCad design PCB/Sensor Board/Sensor Board Ver 0.2.kicad_pcb

Board: 2 copper layers, 116.8 x 11.8 mm, 10 parts (0 on the bottom side), 9 nets.

Parts:
D1, D2, D3, D4: LED; LED-3MM
K1, K2, K3: IR_R_38.5KHZ; SIL-3
P1: CONN_7; SIL-7
R1: R; R3
R2: 5K; RV2

Connections:
IR_Tx: D2.1, D3.1, D4.1, R2.2
unnamed: P1.3, R1.2
unnamed: P1.7, R2.1
unnamed: K1.3, P1.6
unnamed: K2.3, P1.5
unnamed: K3.3, P1.4
unnamed: D1.1, R1.1
VDD: K1.1, K2.1, K3.1, P1.2
VSS: D1.2, D2.2, D3.2, D4.2, K1.2, K2.2, K3.2, P1.1

## KiCad design PCB/Main Board Ver 0.2/Schematic Ver 0.3.kicad_pcb

Parts:
D1: LED; LED-3MM
P1, P2, P5, P10: CONN_01X07
P3, P12: CONN_10
P4: DIL40; DIP-40_W15.24mm
P6: 5V; Pin_Header_Straight_1x02
P7: DAT; Pin_Header_Straight_1x02
P8: GND; Pin_Header_Straight_1x02
P9: CLK; Pin_Header_Straight_1x02
P11: LCD_Interface; Pin_Header_Straight_1x09
P13: Start Buttons; Pin_Header_Straight_1x06
P14, P15, P16, P17: CONN_1
P18: CONN_4
R1, R4, R5: 100 Ohm; Resistor_Horizontal_RM10mm
R2, R3: 10 kOhm; Resistor_Horizontal_RM10mm

Connections:
5V: P4.12, P6.1, P6.2 (PM), P11.8, P12.10, R2.2, R3.2, R5.2
/LCD: P4.34, P11.7
/P1: P4.35, P11.6
/P2: P4.36, P11.3
/P3: P4.37, P13.6
/P4: P4.38, P13.3
IR_Tx: P1.7, P2.7, P4.13, P5.7, P10.7
unnamed: P4.25, P5.3
unnamed: P1.3, P4.17
unnamed: P1.4, P4.16
unnamed: P2.5, P4.19
unnamed: P1.5, P4.15
unnamed: P1.6, P4.14
unnamed: P4.8, P12.2
unnamed: P4.7, P12.3
unnamed: P4.6, P12.4
unnamed: P4.5, P12.5
unnamed: P7.1, P7.2 (PM), R1.2, R2.1
unnamed: P4.39, R4.1
unnamed: P4.40, R1.1
unnamed: P4.3, P18.2
unnamed: P4.4, P18.1
unnamed: P4.2, P18.3
unnamed: P4.1, P18.4
unnamed: P4.26, P10.6
unnamed: P2.4, P4.20
unnamed: P2.3, P4.21
unnamed: P4.22, P5.6
unnamed: P4.23, P5.5
unnamed: P4.27, P10.5
unnamed: P4.28, P10.4
unnamed: P4.33, P10.3
unnamed: D1.1 (A), R5.1
unnamed: P4.24, P5.4
unnamed: P2.6, P4.18
unnamed: P9.1, P9.2 (PM), R3.1, R4.2
VDD: P1.2, P2.2, P4.32, P5.2, P10.2, P11.1, P11.4, P13.1, P13.4
VSS: D1.2 (K), P1.1, P2.1, P4.9, P4.10, P4.29, P5.1, P8.1, P8.2 (PM), P10.1, P11.2, P11.5, P11.9, P12.1, P13.2, P13.5, P14.1, P15.1, P16.1, P17.1

Board: 2 copper layers, 86.7 x 66.9 mm, 24 parts (0 on the bottom side), 38 nets.

## Commit log

2016-12-15 fixed readme
2016-12-15 new files
2016-12-15 added PCB files
2016-12-15 removed backup file
2016-12-22 Added Plots of boards, now ready to be ordered
2016-12-22 Removed extra files
2016-12-22 removed old pcb files, added Autosave file to gitignore
2016-12-22 Removed old plot files, updated schematic to latest - ready for purchase
2016-12-23 Add files via upload
    Updated Proposal
2016-12-23 Add files via upload
    latest proposal
2017-01-07 saved schematic pro file, exported Sumo stls
2017-01-12 added stls, updated 3D model to include USB port, and space for start button selection
2017-01-25 updated model with proper bracket sizes, added bracket drawing, uploaded new stls
2017-02-22 Create Folder
2017-02-22 removed accidental file
2017-02-23 Latest version of sumo model
2017-03-04 new version of wheel, includes molds
2017-03-04 older stl of wheel
2017-03-04 final model of sumo, and .stls
2017-03-15 added some useful source code files
2017-03-15 updated plow, merged lip
2017-03-15 latest plow .stls
2017-03-22 changed pin number
2017-03-22 new motor control code file, uses PIC on Haberly motor controller
2017-03-26 fixed motor control code, had memory collision errors
2017-03-26 removed useless comment
2017-03-27 latest IR test code
2017-03-30 changed frequency
2017-03-30 added basic motor logic
2017-03-30 added test code for kill switches
2017-03-30 added stop codeat end of motor ramp test
2017-03-30 moved freqout to init
2017-03-31 used constants file to get pin numbers, added test code for pushbuttons
2017-03-31 added constants file with pin numbers in it
2017-03-31 changed number of lines from 4 to 2 in LCD init code
2017-03-31 temporarily removed references to serial terminal for testing
2017-03-31 added test code for all four sensor bars
2017-03-31 added pin numbers for sensor bars
2017-04-01 changed 'init' to 'start'
2017-04-01 used pin constant file for transmitter pin as well
2017-04-01 updated lcd_test to use new start function
2017-04-01 removed whitespace
2017-04-01 created initial main code file for sumo
2017-04-01 sumo code with pst disabled
2017-04-01 updated lcd test code to use pin constants file
2017-04-01 changed pin numbers
2017-04-01 fixed problems in code - David, make note of what I changed.
    1. You don't have to say 'return' after the end of a PUB function
    2. the repeat loop in Rightsearch was making the code never get back to the main loop
    3. pst.bin should only display 3 bits, not 5
    otherwise, worked perfectly!
2017-04-02 deleted unused code file
2017-04-02 flipped pin numbers on IRs to correct values
2017-04-02 implemented motor ramping to prevent short circuits, over current draw, and jerking on the motor mounts
2017-04-02 Added lots of start routines, and implemented search code for all four sides of sumo
